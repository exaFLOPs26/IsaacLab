Commit message: real2sim

File: anubis/anubis.urdf (robot description, URDF)
Before this commit: robot anubis, 24 links, 23 joints
Links:
- link OmniFL_wheel: mass 3 -> 4
- link OmniFR_wheel: mass 3 -> 4
- link OmniR_wheel: mass 3 -> 4
- link base_link: mass 50 -> 40
